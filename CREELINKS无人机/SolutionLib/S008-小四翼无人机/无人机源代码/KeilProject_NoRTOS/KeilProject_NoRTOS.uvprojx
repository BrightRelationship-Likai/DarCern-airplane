# Keil uVision project KeilProject_NoRTOS.uvprojx, settings and files
target STM32F103x (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KeilProject_NoRTOS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\ModuleLib;..\..\..\..\StandardLib;..\UserCode;..\..\..\..\TemplateLib\STM32F103X\Stm32f10x;..\KeilProject_NoRTOS;..\..\..\..\TemplateLib\STM32F103X\StandardLib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Stm32f10x
    ../../../../TemplateLib/STM32F103X/Stm32f10x/: core_cm3.c core_cm3.h misc.c misc.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
  group StandardLib
    ../../../../StandardLib/: CeAd.h CeCcp.h CeDa.h CeDebug.h CeExtra.h CeFlash.h CeGpio.h CeI2c.h CeInt.h CePwm.h CeSpi.h CeSystem.h CeTask.h CeTicker.h CeTimer.h CeUart.h Creelinks.h
    ../../../../TemplateLib/STM32F103X/StandardLib/: CeAd.c CeCcp.c CeDa.c CeFlash.c CeGpio.c CeI2c.c CeInt.c CeMcu.h CePwm.c CeSpi.c CeSystem.c CeTimer.c CeUart.c CeDebug.c CeExtra.c CeTask.c CeTicker.c
  group ModuleLib
    ../../../../ModuleLib/: CeBeepNSrc.c CeBeepNSrc.h CeBtnx1.c CeBtnx1.h CeLed1C.c CeLed1C.h CePC33V.c CePC33V.h CeESP8266.c CeESP8266.h CeMPU6050.c CeMPU6050.h CeNRF24L01P.c CeNRF24L01P.h CeMD.c CeMD.h CePCM.c CePCM.h
  group UserCode
    ../UserCode/: CePID.h CeSensor.h CeSensor.c CePID.c CePackage.h CePackage.c CeFilter.h CeFilter.c CeMDCtl.c CeMDCtl.h CeTMCtl.c CeTMCtl.h CeSysCtl.c CeSysCtl.h CeStatus.c CeStatus.h CeParCtl.c CeParCtl.h CePCMCtl.c CePCMCtl.h
    ./: main.c
