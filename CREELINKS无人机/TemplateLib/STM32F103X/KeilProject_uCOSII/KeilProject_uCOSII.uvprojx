# Keil uVision project KeilProject_uCOSII.uvprojx, settings and files
target ELinkSTM_Mini (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KeilProject_uCOSII +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __CE_USE_RTOS__
  c include: ..\..\..\StandardLib;..\..\..\ModuleLib;..\Stm32f10x;..\StandardLib;..\uCOSII;..\UserCode;..\KeilProject_uCOSII
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Stm32f10x
    ../Stm32f10x/: core_cm3.c core_cm3.h misc.c misc.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
  group uCOSII
    ../uCOSII/: app_cfg.h includes.h os_cfg.h os_core.c os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group StandardLib
    ../StandardLib/: CeAd.c CeCcp.c CeDa.c CeDebug.c CeExtra.c CeFlash.c CeGpio.c CeI2c.c CeInt.c CePwm.c CeSpi.c CeSystem.c CeTask.c CeTicker.c CeTimer.c CeUart.c
    ../../../StandardLib/: CeAd.h CeCcp.h CeDa.h CeDebug.h CeExtra.h CeFlash.h CeGpio.h CeI2c.h CeInt.h CePwm.h CeSpi.h CeSystem.h CeTask.h CeTicker.h CeTimer.h CeUart.h Creelinks.h
  group UserCode
    ./: main.c
